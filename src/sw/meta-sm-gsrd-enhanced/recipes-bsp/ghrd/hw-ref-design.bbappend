FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:agilex5_dk_a5e065bb32aes1 += "\
			file://agilex5_dk_a5e065bb32aes1_gsrd_ghrd.core.rbf;name=agilex5_dk_a5e065bb32aes1_gsrd_core_enhanced \
			"

SRC_URI[agilex5_dk_a5e065bb32aes1_gsrd_core_enhanced.sha256sum] += "2957b6097606d0131b34595964a6f8be09bf68f64d981c85ab6ab1fcaf887d9d"
