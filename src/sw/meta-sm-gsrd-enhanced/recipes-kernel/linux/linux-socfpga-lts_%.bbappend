FILESEXTRAPATHS:prepend := "${THISDIR}/linux-socfpga-lts:"

SRC_URI:append:agilex5_dk_a5e065bb32aes1 = " file://0001-Add-support-for-FF-Exercisers-in-Agilex5-device-tree.patch"